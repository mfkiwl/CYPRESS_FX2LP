# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: slave +hex
  AfterMake: hex2bix -i -f 0xC2 slave.iic slave.hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: FW.C DSCR.A51 slave.c EZUSB.LIB USBJmpTb.OBJ Fx2.h fx2regs.h fx2sdly.h syncdly.h timer0.c
